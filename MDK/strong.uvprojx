# Keil uVision project strong.uvprojx, settings and files
target Templat (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\lib\std\inc;..\user;..\bsp\inc;..\lib\freertos\inc;..\task\inc;..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: stm32f4xx_it.c
    ../lib/freertos/inc/: FreeRTOSConfig.h
  group driver
    ../user/: main.c
    ../driver/src/: Driver_DBUS.c Driver_Chassis.c Driver_mpu6500.c Driver_mpu6500_spi.c Driver_PID.c Driver_IST8310.c
  group task
    ../task/src/: Task_test.c Task_Decode.c Task_CANSend.c Task_Control.c Task_Fun.c Task_Init.c Task_Mpu9250.c Task_Weapons.c Tast_Filter.c Task_Dispatch.c Task_Power_Limit.c Task_PID_Calculation.c Task_Cloud_Platforms.c Task_Delay.c Task_ahrs.c Task_Ultrasonic.c
  group bsp
    ../bsp/src/: BSP_GPIO.c BSP_UART.c BSP_NVIC.c BSP_CAN.c BSP_DMA.c BSP_IWDG.c BSP_TIM.c
  group stdlib
    ../lib/std/src/: misc.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_spi.c
  group freertos
    ../lib/freertos/src/: list.c port.c tasks.c timers.c queue.c heap_2.c croutine.c event_groups.c
  group core
    ../core/: system_stm32f4xx.c startup_stm32f427_437xx.s
